# Repository 74th/usb-pd-exporter

File README.md:

# USB PD Exporter

Adapter to extract 5, 9, 12, and 20V power using CH214K, a USB PD Sink controller.

USB PD Sink コントローラである CH214K を使って、5, 9, 12, 20V 電源を取り出すアダプター。

## features

- Output voltage can be changed.
- Can be plugged directly into a breadboard.
- Power on/off switch.
- With reverse current protection circuit.

### Japanese

- 出力電圧を変更することができる。
- ブレッドボードに直接挿すことができる。
- 電源のオンオフボタンがある。
- 逆電流保護回路付き。

## Attention

This product is the work of an electrician hobbyist.
We do not guarantee any damage in the use of this product.
Use at your own risk.

このプロダクトは電気工作の趣味人の作品です。
これの使用における損害は一切保証致しません。
自己責任で利用ください。

## v1.0.1

- Semantics [PDF](./usb_pd_exporter-v1.0.1-semantics.pdf) [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fusb-pd-exporter%2Fblob%2F1.0.1%2Fusb_pd_exporter.kicad_sch)
- PCB [kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2F74th%2Fusb-pd-exporter%2Fblob%2F1.0.1%2Fusb_pd_exporter.kicad_pcb)

### BOM

| Reference | Name                                     | Quantity |
| --------- | ---------------------------------------- | -------- |
| C1, C2    | Capacitor 0805 1uF                       | 2        |
| R1, R4    | Register 0805 1kΩ                        | 2        |
| R2, R5    | Register 0805 10kΩ                       | 2        |
| R3        | Register 0805 100kΩ                      | 1        |
| CH1       | Terminal Block 2P 5.08mm                 | 1        |
| CH2, CH3  | Pin Header 2 Pith 2.54mm                 | 2        |
| CH4       | DC Barrel Jack                           | 1        |
| J1        | USB Type-C Receptacle - USB-C 2.0 Female | 1        |
| JP1       | Jumper CFG1                              | 1        |
| JP2       | Jumper CFG3                              | 1        |
| JP3       | Jumper CFG2                              | 1        |
| Q1        | Pch Dual MOSFET SOIC-8 FDS4935A          | 1        |
| SW1       | Locking Switch                           | 1        |
| U1        | USB PD Sink IC ESSOP-10 CH224K           | 1        |

## LICENSE

MIT

日本国内においては、販売はしないでいただけるとありがたいです。

## KiCad design usb_pd_exporter.kicad_pcb

Parts:
C1, C2: 1u; Capacitor_0805_2012
CH1: Terminal; TerminalBlock_bornier-2_P5.08mm
CH2, CH3: PinHeader-2; 2Pin
CH4: Barrel_Jack_Switch; DCJack-BarrelJack
J1: USB-C 2.0 Female; USB-C-12-Pin-MidMount-ali-v5
JP1: CFG1; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: CFG3; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: CFG2; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: FDS4935A; SOIC-8_3.9x4.9mm_P1.27mm
R1, R4: 1k; Register_0805_2012
R2, R5: 10k; Register_0805_2012
R3: 100k; Register_0805_2012
SW1: Locking_Switch; Locking_Button_8x8mm
U1: CH224K; ESSOP-10_3.9x5.0mm_P1.0

Connections:
/CC1: J1.5 (CC1), U1.7 (CC1)
/CC2: J1.6 (CC2), U1.6 (CC2)
/CFG1: JP1.2 (C), U1.9 (CFG1)
/CFG2: JP3.2 (C), U1.2 (CFG2)
/CFG3: JP2.2 (C), U1.3 (CFG3)
/D+: J1.3 (D+), U1.4 (DP)
/D-: J1.2 (D-), U1.5 (DM)
/PG: SW1.2 (C), U1.10 (PG)
/VOUT: C2.1, CH1.1, CH2.1 (VDD), CH3.1 (VDD), CH4.1, Q1.7, Q1.8
/~Enable: R5.1, SW1.1 (B)
GND: C1.2, CH1.2, CH2.2 (VSS), CH3.2 (VSS), CH4.2, J1.4 (GND), JP1.3 (B), JP2.3 (B), JP3.3 (B), SW1.4 (E), SW1.5 (F), SW1.6 (D), U1.0 (GND)
unnamed: C2.2, R4.2
unnamed: Q1.1, Q1.3, R3.1
unnamed: Q1.2, Q1.4, R3.2, R4.1, R5.2
unnamed: R2.1, U1.8 (VBUS)
VBUS: J1.1 (VBUS), Q1.5, Q1.6, R1.2, R2.2, SW1.3 (A)
VDD: C1.1, JP1.1 (A), JP2.1 (A), JP3.1 (A), R1.1, U1.1 (VDD)

Notes on the sheet:
Output
じがへるつさんの 『Type-C電子工作クックブック』より
USB Socket
PDによる電力供給が正しいとき PG(Power Good)はLになる
4-6はGNDベタを確保したかったため
~{Enable}がLになると送電される 逆電流防止
Power Switch
Config
USB PD Sink Controller

Board: 2 copper layers, 29.2 x 41.5 mm, 24 parts (8 on the bottom side), 17 nets.

Other parts of the board:
M1, M2, M3, M4: M2_v2
MISC-ACCOUNTTEXT: 74th-text
MISC-ICON: LOGO; 74th-5mm

## Commit log

2023-09-07 v1.0.1
